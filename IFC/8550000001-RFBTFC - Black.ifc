Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 9b847cb6-1786-45f5-8e35-42dce8d496a2, NumberOfSaves: 34]
File name: Project Number
Time: 2024-01-29T11:22:53+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.30.97 (ENU) - IFC 23.3.1.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingElementProxy: NLRSen_57_AT_UN_RFB_Solid_Air:RFBTFC - Black, NLRSen_57_AT_UN_RFB_Solid_Air:RFBTFC - Black:2299494
In: Default
Type - Description: Floor Swirl Diffuser - Floor max 50mm thick; Material: Polycarbonate ABS - Grey, Polycarbonate ABS - Dark Grey
Type - Other - Category: Air Terminals; Family Name: NLRSen_57_AT_UN_RFB_Solid_Air; index: 2
Type - Constraints - Default Elevation: 0 mm
Type - General - SACS_Revised_by: J. Feeke; SACS_Revision_Date: 26-01-2021; SACS_Revision_Number: 2.03
Type - Identity Data - Assembly Code: 57.00; Description: Floor Swirl Diffuser - Floor max 50mm thick; Manufacturer: Solid Air Climate Solutions; Model: RFBTFC - Black; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 26-01-2021; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 2.03; NLRS_C_description: Floor Swirl Diffuser - Floor max 50mm thick; NLRS_C_materiaal_kleur: Zwart; Type Name: RFBTFC - Black; URL: https://solid-air.nl/producten/roosters/vloer--en-verdringingsroosters/vloerrooster-rfb
Type - Materials and Finishes - SACS_Color: Zwart; SACS_Face_Color: Polycarbonate ABS - Black
Type - Mechanical - Flow - Max Flow: 55 dm3/s; Min Flow: 30 dm3/s
Type - Visibility - SACS_Show_Label: yes
Type - Pset_ConcreteElementGeneral - FireRating: 00
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Classification: 57.00 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: RFBTFC - Black; sets with these values: 2
Other - Family: NLRSen_57_AT_UN_RFB_Solid_Air; Family and Type: NLRSen_57_AT_UN_RFB_Solid_Air: RFBTFC - Black; Type: RFBTFC - Black; Type Id: 2289369
Model Properties - SACS_Damper_Open_%: 0
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.203246 m2; Floor_Thickness: 25 mm; NLRS_M_c01_diameter: 210 mm; Volume: 0.000484989 m3
Identity Data - Mark: 10140; NLRS_C_model: RFBTFC - Black; SACS_Article_Code: 8550000001; SACS_Gross_Cost: 163; SACS_Price_Version: 202001
Mechanical - Flow - NLRS_M_c01_debiet: 0 dm3/s
Phasing - Phase Created: New Construction
Text - SACS_Warning_Text_Flow: Flow outside specification values!
Visibility - SACS_Arrows_Visible: yes; SACS_Warning_Disable: no; Show_Top_Grill: yes
